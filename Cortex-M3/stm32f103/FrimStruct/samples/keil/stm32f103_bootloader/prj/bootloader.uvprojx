# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\src\sys\delay;..\src\sys\pub;..\src\sys\uart;..\src\sys\led;..\src\sys\timer;..\src\app\ymodem;..\src\app\comm;..\src\app\download
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../src/app/: main.c bsp.c
    ../src/app/comm/: common.c
    ../src/app/download/: download.c
    ../src/app/ymodem/: ymodem.c
  group sys
    ../src/sys/pub/: pub.c
    ../src/sys/led/: led.c
    ../src/sys/uart/: uart.c
    ../src/sys/timer/: BspTime2.c BspTime3.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
