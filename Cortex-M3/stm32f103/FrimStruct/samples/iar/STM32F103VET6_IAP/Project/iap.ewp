# IAR project iap.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VE ST STM32F103VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_PERIPH_DRIVER; USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: E:\STM32-IAR\STM32F103VET6_IAP; E:\STM32-IAR\STM32F103VET6_IAP\FWLIB\inc; E:\STM32-IAR\STM32F103VET6_IAP\CMSIS\Startup; E:\STM32-IAR\STM32F103VET6_IAP\CMSIS\System; E:\STM32-IAR\STM32F103VET6_IAP\User
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: iap.hex
  ILINK.IlinkOutputFile: iap.out
  ILINK.IlinkIcfFile: E:\STM32-IAR\STM32F103VET6_IAP\Config\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS/Startup
    ../CMSIS/Startup/: startup_stm32f10x_hd.s
  group CMSIS/System
    ../CMSIS/System/: system_stm32f10x.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: Common.c flash_if.c main.c Menu.c stm32f10x_it.c ymodem.c
